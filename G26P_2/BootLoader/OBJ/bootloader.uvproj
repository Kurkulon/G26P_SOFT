# Keil uVision project bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SAM4SA16B Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: bootloader
  c flags: Optim=1
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000

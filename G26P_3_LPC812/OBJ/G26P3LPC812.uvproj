# Keil uVision project G26P3LPC812.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC812M101 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: G26P3LPC812
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC43xx.s

# Keil uVision project G26P_3_V2_BOOT_LPC824.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: G26P_3_V2_BOOT_LPC824
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000

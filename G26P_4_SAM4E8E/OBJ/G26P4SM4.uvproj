# Keil uVision project G26P4SM4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SAM4E8E Atmel
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x400000-0x47FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: G26P4SM4
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000

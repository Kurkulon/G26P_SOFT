# Keil uVision project G26P_4_BOOT_XMC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: XMC4800-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.12.1
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G26P_4_BOOT_XMC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
